# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC90C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\PORT;.\UCOSII
  group Source Group 1
    ./: STARTUP.A51 main.c
  group UCOSII
    ./UCOSII/: OS_CORE.C OS_FLAG.C OS_MBOX.C OS_MEM.C OS_MUTEX.C OS_Q.C OS_SEM.C OS_TASK.C OS_TIME.C uCOS_II.H
  group PORT
    ./PORT/: OS_CPU_A.ASM OS_CPU_C.C
    ./: OS_CFG.H OS_CPU.H
